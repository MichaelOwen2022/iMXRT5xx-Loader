# IAR project crank_storyboard_helloworld.ewp, settings and files
configuration flash_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT595S_M33 NXP MIMXRT595S_M33
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; BOOT_HEADER_ENABLE=1; CPU_MIMXRT595SFFOC_cm33; GRE_TARGET_OS_freertos; GRE_TARGET_CPU_cortexm7; GRE_FEATURE_VFS_RESOURCES; PRINTF_FLOAT_ENABLE=1; SCANF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=1; BOARD_ENABLE_PSRAM_CACHE=0; SSD1963_DATA_WITDH=8; FLEXIO_MCULCD_DATA_BUS_WIDTH=8; DBI_FLEXIO_USE_SMARTDMA=1; DEMO_PANEL=DEMO_PANEL_RM67162; SDK_OS_FREE_RTOS; CUSTOM_VGLITE_MEMORY_CONFIG=1; SDK_I2C_BASED_COMPONENT_USED=1; VG_COMMAND_CALL=1; VG_TARGET_FAST_CLEAR=0; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../..; ../../../../../rtos/freertos/freertos_kernel/include; ../../../../../middleware/Crank_Software/cortexM-vglite/include/freertos; ../../../../../middleware/Crank_Software/cortexM-vglite/include; ../../../../../devices/MIMXRT595S/drivers; ../../../../../components/ssd1963; ../../../../../components/video/display/dbi; ../../../../../components/video/display/dbi/flexio; ../../../../../components/video/display/dc/ssd1963; ../../../../../components/video/display/dc/lcdif; ../../../../../components/video; ../../../../../components/video/display; ../../../../../components/video/display/rm68191; ../../../../../components/video/display/mipi_dsi_cmd; ../../../../../components/video/display/rm68200; ../../../../../components/video/display/rm67162; ../../../../../components/video/display/dc/dsi_cmd; ../../../../../components/ft3267; ../../../../../components/gt911; ../../../../../components/ft5406; ../../../../../components/video/display/fbdev; ../../../../../devices/MIMXRT595S/utilities/debug_console_lite; ../../../../../rtos/freertos/freertos_kernel/portable/IAR/ARM_CM33_NTZ/non_secure; ../../../../../components/video/display/hx8394; ../../../../../devices/MIMXRT595S; ../../../../../components/uart; ../../../../../components/lists; ../../../flash_config; ../../../../../middleware/vglite/inc; ../../../../../middleware/vglite/font; ../../../../../middleware/vglite/font/mcufont/decoder; ../../../../../middleware/vglite/VGLite/rtos; ../../../../../middleware/vglite/VGLiteKernel; ../../../../../middleware/vglite/VGLiteKernel/rtos; ../../../../../CMSIS/Core/Include; ../../../../../components/video/display/dc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ..; ../../..
  OBJCOPY.OOCOutputFile: sdk20-app.bin
  ILINK.IlinkOutputFile: crank_storyboard_helloworld.out
  ILINK.IlinkIcfFile: MIMXRT595Sxxxx_cm33_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../middleware/Crank_Software/cortexM-vglite/lib/CM33-iar/libgre.a; ../../../../../middleware/Crank_Software/cortexM-vglite/lib/CM33-iar/libgreal.a; ../../../../../middleware/Crank_Software/cortexM-vglite/lib/CM33-iar/libsbimage.a; ../../../../../middleware/Crank_Software/cortexM-vglite/lib/CM33-iar/libsbvfs.a; ../../../../../middleware/Crank_Software/cortexM-vglite/plugins/CM33-iar/libgre-plugin-animation.a; ../../../../../middleware/Crank_Software/cortexM-vglite/plugins/CM33-iar/libgre-plugin-gesture.a; ../../../../../middleware/Crank_Software/cortexM-vglite/plugins/CM33-iar/libgre-plugin-circle.a; ../../../../../middleware/Crank_Software/cortexM-vglite/plugins/CM33-iar/libgre-plugin-greio.a; ../../../../../middleware/Crank_Software/cortexM-vglite/plugins/CM33-iar/libgre-plugin-logger.a; ../../../../../middleware/Crank_Software/cortexM-vglite/plugins/CM33-iar/libgre-plugin-lua.a; ../../../../../middleware/Crank_Software/cortexM-vglite/plugins/CM33-iar/libgre-plugin-metrics.a; ../../../../../middleware/Crank_Software/cortexM-vglite/plugins/CM33-iar/libgre-plugin-poly.a; ../../../../../middleware/Crank_Software/cortexM-vglite/plugins/CM33-iar/libgre-plugin-trace.a; ../../../../../middleware/Crank_Software/cortexM-vglite/plugins/CM33-iar/libgre-plugin-screen-drag.a; ../../../../../middleware/Crank_Software/cortexM-vglite/plugins/CM33-iar/libgre-plugin-screen-path.a; ../../../../../middleware/Crank_Software/cortexM-vglite/plugins/CM33-iar/libgre-plugin-timer.a; ../../../../../middleware/Crank_Software/cortexM-vglite/plugins/CM33-iar/libgre-plugin-sbimage-soil.a; ../../../../../middleware/Crank_Software/cortexM-vglite/plugins/CM33-iar/libfont-plugin-freetype.a; ../../../../../middleware/Crank_Software/cortexM-vglite/plugins/CM33-iar/librender-plugin-vglite.a; ../../../../../middleware/Crank_Software/cortexM-vglite/lib/CM33-iar/liblogging-util.a; ../../../../../middleware/Crank_Software/cortexM-vglite/lib/CM33-iar/libgreio.a; ../../../../../middleware/Crank_Software/cortexM-vglite/lib/CM33-iar/libswrender.a; ../../../../../middleware/Crank_Software/cortexM-vglite/lib/CM33-iar/libsbfreetype.a; ../../../../../middleware/Crank_Software/cortexM-vglite/lib/CM33-iar/libsblua.a; ../../../../../middleware/Crank_Software/cortexM-vglite/lib/CM33-iar/libsoil.a; ../../../../../middleware/Crank_Software/cortexM-vglite/lib/CM33-iar/libpng.a; ../../../../../middleware/Crank_Software/cortexM-vglite/lib/CM33-iar/libsbz.a
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flash_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; CPU_MIMXRT595SFFOC_cm33; BOOT_HEADER_ENABLE=1; NDEBUG; GRE_TARGET_OS_freertos; GRE_TARGET_CPU_cortexm7; GRE_FEATURE_VFS_RESOURCES; PRINTF_FLOAT_ENABLE=1; SCANF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=1; BOARD_ENABLE_PSRAM_CACHE=0; SSD1963_DATA_WITDH=8; FLEXIO_MCULCD_DATA_BUS_WIDTH=8; DBI_FLEXIO_USE_SMARTDMA=1; DEMO_PANEL=DEMO_PANEL_RM67162; SDK_OS_FREE_RTOS; CUSTOM_VGLITE_MEMORY_CONFIG=1; SDK_I2C_BASED_COMPONENT_USED=1; VG_COMMAND_CALL=1; VG_TARGET_FAST_CLEAR=0; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 3
  group source
    ../: HelloWorld.h sbengine_task_vglite.c sbengine_plugins.h storyboard_freertos.c FreeRTOSConfig.h
  group board
    ../: display_support.c pin_mux.c pin_mux.h vglite_support.c vglite_support.h touch.c touch.h display_support.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group freertos/freertos_kernel
    ../../../../../rtos/freertos/freertos_kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos_kernel/include
    ../../../../../rtos/freertos/freertos_kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group freertos/freertos_kernel/portable
    ../../../../../rtos/freertos/freertos_kernel/portable/: readme.txt
  group freertos/freertos_kernel/portable/MemMang
    ../../../../../rtos/freertos/freertos_kernel/portable/MemMang/: ReadMe.url heap_3.c
  group freertos/freertos_kernel/portable/IAR/ARM_CM33_NTZ/non_secure
    ../../../../../rtos/freertos/freertos_kernel/portable/IAR/ARM_CM33_NTZ/non_secure/: port.c portasm.h portasm.s portmacro.h
  group drivers
    ../../../../../devices/MIMXRT595S/drivers/: fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_clock.h fsl_clock.c fsl_flexio.c fsl_flexio.h fsl_flexio_mculcd.c fsl_flexio_mculcd.h fsl_dma.c fsl_dma.h fsl_gpio.h fsl_gpio.c fsl_inputmux.h fsl_inputmux.c fsl_flexio_mculcd_smartdma.c fsl_flexio_mculcd_smartdma.h fsl_mipi_dsi.c fsl_mipi_dsi.h fsl_lcdif.h fsl_lcdif.c fsl_i2c.h fsl_i2c.c fsl_mipi_dsi_smartdma.c fsl_mipi_dsi_smartdma.h fsl_power.h fsl_power.c fsl_flexspi.c fsl_flexspi.h fsl_cache.c fsl_cache.h fsl_usart.h fsl_usart.c fsl_flexcomm.h fsl_flexcomm.c fsl_iopctl.h fsl_reset.h fsl_reset.c fsl_smartdma.h fsl_smartdma.c fsl_smartdma_prv.h fsl_inputmux_connections.h fsl_soc_mipi_dsi.h fsl_iap.h fsl_iap.c
  group lcdc
    ../../../../../components/ssd1963/: fsl_ssd1963.h fsl_ssd1963.c
  group video
    ../../../../../components/video/display/dbi/: fsl_dbi.h
    ../../../../../components/video/display/dbi/flexio/: fsl_dbi_flexio_smartdma.h fsl_dbi_flexio_smartdma.c
    ../../../../../components/video/display/dc/ssd1963/: fsl_dc_fb_ssd1963.h fsl_dc_fb_ssd1963.c
    ../../../../../components/video/display/dc/lcdif/: fsl_dc_fb_lcdif.h fsl_dc_fb_lcdif.c
    ../../../../../components/video/: fsl_video_common.h fsl_video_common.c
    ../../../../../components/video/display/: fsl_display.h
    ../../../../../components/video/display/rm68191/: fsl_rm68191.h fsl_rm68191.c
    ../../../../../components/video/display/mipi_dsi_cmd/: fsl_mipi_dsi_cmd.h fsl_mipi_dsi_cmd.c
    ../../../../../components/video/display/rm68200/: fsl_rm68200.h fsl_rm68200.c
    ../../../../../components/video/display/rm67162/: fsl_rm67162.h fsl_rm67162.c
    ../../../../../components/video/display/dc/dsi_cmd/: fsl_dc_fb_dsi_cmd.h fsl_dc_fb_dsi_cmd.c
    ../../../../../components/video/display/fbdev/: fsl_fbdev.h fsl_fbdev.c
    ../../../../../components/video/display/hx8394/: fsl_hx8394.h fsl_hx8394.c
    ../../../../../components/video/display/dc/: fsl_dc_fb.h
  group touchpanel
    ../../../../../components/ft3267/: fsl_ft3267.h fsl_ft3267.c
    ../../../../../components/gt911/: fsl_gt911.h fsl_gt911.c
    ../../../../../components/ft5406/: fsl_ft5406.h fsl_ft5406.c
  group utilities
    ../../../../../devices/MIMXRT595S/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group device
    ../../../../../devices/MIMXRT595S/: fsl_device_registers.h MIMXRT595S_cm33.h MIMXRT595S_cm33_features.h system_MIMXRT595S_cm33.c system_MIMXRT595S_cm33.h
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_usart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group flash_config
    ../../../flash_config/: flash_config.c flash_config.h
  group startup
    ../../../../../devices/MIMXRT595S/iar/: startup_MIMXRT595S_cm33.s
  group vglite
    ../../../../../middleware/vglite/: ChangeLogKSDK.txt
  group vglite/inc
    ../../../../../middleware/vglite/inc/: vg_lite.h vg_lite_hal.h vg_lite_text.h
  group vglite/VGLite
    ../../../../../middleware/vglite/VGLite/: vg_lite.c vg_lite_image.c vg_lite_matrix.c vg_lite_path.c
  group vglite/VGLite/rtos
    ../../../../../middleware/vglite/VGLite/rtos/: vg_lite_os.h vg_lite_os.c
  group vglite/font
    ../../../../../middleware/vglite/font/: buf_reader.c buf_reader.h fonts.h rle_font_read.c vft_debug.c vft_debug.h vft_draw.c vft_draw.h vg_lite_text.c
  group vglite/font/mcufont
    ../../../../../middleware/vglite/font/mcufont/: LICENSE
  group vglite/font/mcufont/decoder
    ../../../../../middleware/vglite/font/mcufont/decoder/: mcufont.h mf_bwfont.c mf_bwfont.h mf_config.h mf_encoding.c mf_encoding.h mf_font.c mf_font.h mf_justify.c mf_justify.h mf_kerning.c mf_kerning.h mf_rlefont.c mf_rlefont.h mf_scaledfont.c mf_scaledfont.h mf_wordwrap.c mf_wordwrap.h
  group vglite/VGLiteKernel
    ../../../../../middleware/vglite/VGLiteKernel/: vg_lite_hw.h vg_lite_kernel.h vg_lite_kernel.c
  group vglite/VGLiteKernel/rtos
    ../../../../../middleware/vglite/VGLiteKernel/rtos/: vg_lite_hal.c vg_lite_platform.h
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
