# Keil uVision project tensorflow_lite_micro_kws_cm33.uvprojx, settings and files
target tensorflow_lite_micro_kws_cm33 flash_debug (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT595SFFOC:cm33 NXP
  pack: NXP.MIMXRT595S_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: tensorflow_lite_micro_kws_cm33.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=4 wLevel=3
  c define: DEBUG, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, __STDC_CONSTANT_MACROS, __CLK_TCK=1000000, CPU_MIMXRT595SFFOC_cm33, BOOT_HEADER_ENABLE=1, SDK_DEBUGCONSOLE_UART, ARM_MATH_CM33, __FPU_PRESENT=1, SDK_I2C_BASED_COMPONENT_USED=1, BOARD_USE_CODEC=1, CODEC_WM8904_ENABLE, DISABLEFLOAT16, TF_LITE_STATIC_MEMORY, CMSIS_NN, MCUXPRESSO_SDK
  c misc: -ffp-mode=full  -fno-exceptions  -Wno-c++17-extensions  -fno-common  -fdata-sections  -mthumb
  c include: ../../../../../middleware/eiq/tensorflow-lite/examples/kws;../../../../../middleware/eiq/tensorflow-lite/examples/common/audio;../../../../../middleware/eiq/common/audio;../../../../../middleware/eiq/common/model;../../../../../middleware/eiq/common;..;../../../../../devices/MIMXRT595S/utilities/debug_console_lite;../../../../../components/codec/i2c;../../../../../devices/MIMXRT595S/drivers;../../../../../components/i2c;../../../../../components/codec;../../../../../components/codec/port/wm8904;../../../../../components/codec/port;../../../../../components/codec/wm8904;../../../../../middleware/eiq/common/audio/rtxxx;../../../../../CMSIS/DSP/Include;../../../../../CMSIS/DSP/PrivateInclude;../../../../../CMSIS/DSP/Source/DistanceFunctions;../../../../../middleware/eiq/tensorflow-lite;../../../../../components/lists;../../../../../components/uart;../../../../../devices/MIMXRT595S;../../../flash_config;../../../../../CMSIS/Core/Include;../../../../../middleware/eiq/tensorflow-lite/third_party/flatbuffers/include;../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp;../../../../../middleware/eiq/tensorflow-lite/third_party/ruy;../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis;../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Include;../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/CMSIS/Core/Include;../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/CMSIS/DSP/Include
  asm define: DEBUG
  memory RVCT1: ROM 0x10000000 size 0x20000
  memory RVCT2: ROM 0x20000000 size 0x20000
  memory RVCT3: ROM 0x30000000 size 0x20000
  memory RVCT4: ROM 0x3000000 size 0x20000
  memory RVCT5: ROM 0x13000000 size 0x20000
  memory RVCT6: RAM 0x10300000 size 0x200000
  memory RVCT7: RAM 0x20300000 size 0x200000
  memory RVCT8: RAM 0x30300000 size 0x200000
  memory RVCT9: RAM 0x80000 size 0x280000
  memory RVCT10: RAM 0x300000 size 0x200000
  scatter file: MIMXRT595Sxxxx_cm33_flash.scf
  link misc: --remove --predefine="-D__stack_size__=0x10000" --predefine="-D__heap_size__=0x80000" --entry=Reset_Handler
  group source
    ../../../../../middleware/eiq/common/: demo_info.h timer.h timer.c
    ../../../../../middleware/eiq/tensorflow-lite/examples/kws/: audio_data.h demo_config.h labels.h main.cpp
    ../../../../../middleware/eiq/tensorflow-lite/examples/common/: demo_info.cpp
  group source/model
    ../../../../../middleware/eiq/common/model/: get_top_n.cpp get_top_n.h model.h output_postproc.h
    ../../../../../middleware/eiq/tensorflow-lite/examples/: model.cpp
    ../../../../../middleware/eiq/tensorflow-lite/examples/kws/: output_postproc.cpp model_data.h model_ds_cnn_ops_micro.cpp
  group source/audio
    ../../../../../middleware/eiq/common/audio/: audio.h
    ../../../../../middleware/eiq/tensorflow-lite/examples/common/audio/: kws_mfcc.cpp kws_mfcc.hpp mfcc.cpp mfcc.hpp
    ../../../../../middleware/eiq/common/audio/rtxxx/: audio_stream.c audio_capture.cpp audio_stream.h
  group doc
    ../../../../../middleware/eiq/tensorflow-lite/examples/kws/: ds_cnn_s.tflite off.wav right.wav train.py
    ../: readme.txt
  group board
    ../: clock_config.c clock_config.h pin_mux.c pin_mux.h board.c board.h board_init.c board_init.h
    ./: retarget.c
  group utilities
    ../../../../../devices/MIMXRT595S/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group codec
    ../../../../../components/codec/i2c/: fsl_codec_i2c.h fsl_codec_i2c.c
    ../../../../../components/codec/: fsl_codec_common.h fsl_codec_common.c
    ../../../../../components/codec/wm8904/: fsl_wm8904.h fsl_wm8904.c
  group drivers
    ../../../../../devices/MIMXRT595S/drivers/: fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_dmic.c fsl_dmic.h fsl_dmic_dma.c fsl_dmic_dma.h fsl_i2c.h fsl_i2c.c fsl_i2s.h fsl_i2s.c fsl_i2s_dma.h fsl_i2s_dma.c fsl_usart.h fsl_usart.c fsl_i3c.h fsl_i3c.c fsl_inputmux.h fsl_inputmux.c fsl_inputmux_connections.h fsl_dma.c fsl_dma.h fsl_cache.c fsl_cache.h fsl_clock.h fsl_clock.c fsl_flexcomm.h fsl_flexcomm.c fsl_flexspi.c fsl_flexspi.h fsl_gpio.h fsl_gpio.c fsl_iopctl.h fsl_power.h fsl_power.c fsl_reset.h fsl_reset.c fsl_iap.h fsl_iap.c
  group component/i2c
    ../../../../../components/i2c/: fsl_adapter_i2c.h fsl_adapter_i3c.c
  group codec/port/wm8904
    ../../../../../components/codec/port/wm8904/: fsl_codec_wm8904_adapter.c fsl_codec_wm8904_adapter.h
  group codec/port
    ../../../../../components/codec/port/: fsl_codec_adapter.h
  group CMSIS/DSP/Include
    ../../../../../CMSIS/DSP/Include/: arm_common_tables.h arm_const_structs.h arm_math.h arm_common_tables_f16.h arm_const_structs_f16.h arm_helium_utils.h arm_math_f16.h arm_math_memory.h arm_math_types.h arm_math_types_f16.h arm_mve_tables.h arm_mve_tables_f16.h arm_vec_math.h arm_vec_math_f16.h
  group CMSIS/DSP/Include/dsp
    ../../../../../CMSIS/DSP/Include/dsp/: basic_math_functions.h basic_math_functions_f16.h bayes_functions.h bayes_functions_f16.h complex_math_functions.h complex_math_functions_f16.h controller_functions.h controller_functions_f16.h distance_functions.h distance_functions_f16.h fast_math_functions.h fast_math_functions_f16.h filtering_functions.h filtering_functions_f16.h interpolation_functions.h interpolation_functions_f16.h matrix_functions.h matrix_functions_f16.h none.h quaternion_math_functions.h statistics_functions.h statistics_functions_f16.h support_functions.h support_functions_f16.h svm_defines.h svm_functions.h svm_functions_f16.h transform_functions.h transform_functions_f16.h utils.h
  group CMSIS/DSP/PrivateInclude
    ../../../../../CMSIS/DSP/PrivateInclude/: arm_sorting.h arm_vec_fft.h arm_vec_filtering.h
  group CMSIS/DSP/Source/BasicMathFunctions
    ../../../../../CMSIS/DSP/Source/BasicMathFunctions/: BasicMathFunctions.c BasicMathFunctionsF16.c
  group CMSIS/DSP/Source/BayesFunctions
    ../../../../../CMSIS/DSP/Source/BayesFunctions/: BayesFunctions.c BayesFunctionsF16.c
  group CMSIS/DSP/Source/CommonTables
    ../../../../../CMSIS/DSP/Source/CommonTables/: CommonTables.c CommonTablesF16.c
  group CMSIS/DSP/Source/ComplexMathFunctions
    ../../../../../CMSIS/DSP/Source/ComplexMathFunctions/: ComplexMathFunctions.c ComplexMathFunctionsF16.c
  group CMSIS/DSP/Source/ControllerFunctions
    ../../../../../CMSIS/DSP/Source/ControllerFunctions/: ControllerFunctions.c
  group CMSIS/DSP/Source/DistanceFunctions
    ../../../../../CMSIS/DSP/Source/DistanceFunctions/: DistanceFunctions.c arm_boolean_distance_template.h DistanceFunctionsF16.c
  group CMSIS/DSP/Source/FastMathFunctions
    ../../../../../CMSIS/DSP/Source/FastMathFunctions/: FastMathFunctions.c FastMathFunctionsF16.c
  group CMSIS/DSP/Source/FilteringFunctions
    ../../../../../CMSIS/DSP/Source/FilteringFunctions/: FilteringFunctions.c FilteringFunctionsF16.c
  group CMSIS/DSP/Source/InterpolationFunctions
    ../../../../../CMSIS/DSP/Source/InterpolationFunctions/: InterpolationFunctions.c InterpolationFunctionsF16.c
  group CMSIS/DSP/Source/MatrixFunctions
    ../../../../../CMSIS/DSP/Source/MatrixFunctions/: MatrixFunctions.c MatrixFunctionsF16.c
  group CMSIS/DSP/Source/QuaternionMathFunctions
    ../../../../../CMSIS/DSP/Source/QuaternionMathFunctions/: QuaternionMathFunctions.c
  group CMSIS/DSP/Source/SVMFunctions
    ../../../../../CMSIS/DSP/Source/SVMFunctions/: SVMFunctions.c SVMFunctionsF16.c
  group CMSIS/DSP/Source/StatisticsFunctions
    ../../../../../CMSIS/DSP/Source/StatisticsFunctions/: StatisticsFunctions.c StatisticsFunctionsF16.c
  group CMSIS/DSP/Source/SupportFunctions
    ../../../../../CMSIS/DSP/Source/SupportFunctions/: SupportFunctions.c SupportFunctionsF16.c
  group CMSIS/DSP/Source/TransformFunctions
    ../../../../../CMSIS/DSP/Source/TransformFunctions/: TransformFunctions.c TransformFunctionsF16.c
  group eiq/tensorflow-lite
    ../../../../../middleware/eiq/tensorflow-lite/: AUTHORS LICENSE NOTICE ChangeLogKSDK.txt readme.txt
  group eiq/tensorflow-lite/tensorflow/lite
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/: portable_type_to_tflitetype.h
  group eiq/tensorflow-lite/tensorflow/lite/c
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/c/: common.h common.c builtin_op_data.h c_api_types.h
  group eiq/tensorflow-lite/tensorflow/lite/core/api
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/core/api/: error_reporter.h flatbuffer_conversions.h op_resolver.h tensor_utils.h error_reporter.cpp flatbuffer_conversions.cpp op_resolver.cpp tensor_utils.cpp
  group eiq/tensorflow-lite/tensorflow/lite/kernels
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/: kernel_util.h kernel_utils.cpp op_macros.h padding.h
  group eiq/tensorflow-lite/tensorflow/lite/kernels/internal
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/internal/: common.h compatibility.h cppmath.h max.h min.h portable_tensor.h portable_tensor_utils.h quantization_util.h quantization_util.cpp runtime_shape.h strided_slice_logic.h tensor_ctypes.h types.h
  group eiq/tensorflow-lite/tensorflow/lite/kernels/internal/optimized
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/internal/optimized/: neon_check.h
  group eiq/tensorflow-lite/tensorflow/lite/kernels/internal/reference
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/internal/reference/: add.h add_n.h arg_min_max.h batch_to_space_nd.h binary_function.h ceil.h comparisons.h concatenation.h conv.h cumsum.h depth_to_space.h depthwiseconv_float.h depthwiseconv_uint8.h dequantize.h elu.h exp.h fill.h floor.h floor_div.h floor_mod.h fully_connected.h hard_swish.h l2normalization.h leaky_relu.h log_softmax.h logistic.h maximum_minimum.h mul.h neg.h pad.h pooling.h portable_tensor_utils_impl.h prelu.h process_broadcast_shapes.h quantize.h reduce.h requantize.h resize_bilinear.h resize_nearest_neighbor.h round.h slice.h softmax.h space_to_batch_nd.h space_to_depth.h strided_slice.h sub.h tanh.h transpose.h transpose_conv.h portable_tensor_utils.cpp
  group eiq/tensorflow-lite/tensorflow/lite/kernels/internal/reference/integer_ops
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/internal/reference/integer_ops/: add.h conv.h depthwise_conv.h fully_connected.h l2normalization.h logistic.h mean.h mul.h pooling.h tanh.h transpose_conv.h
  group eiq/tensorflow-lite/tensorflow/lite/micro
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/micro/: all_ops_resolver.cpp all_ops_resolver.h compatibility.h debug_log.cpp debug_log.h fake_micro_context.cpp fake_micro_context.h flatbuffer_utils.cpp flatbuffer_utils.h memory_helpers.cpp memory_helpers.h micro_allocator.cpp micro_allocator.h micro_arena_constants.h micro_context.cpp micro_context.h micro_error_reporter.cpp micro_error_reporter.h micro_graph.cpp micro_graph.h micro_interpreter.cpp micro_interpreter.h micro_mutable_op_resolver.h micro_op_resolver.h micro_profiler.cpp micro_profiler.h micro_resource_variable.cpp micro_resource_variable.h micro_string.cpp micro_string.h micro_time.cpp micro_time.h micro_utils.cpp micro_utils.h recording_micro_allocator.cpp recording_micro_allocator.h recording_simple_memory_allocator.cpp recording_simple_memory_allocator.h simple_memory_allocator.cpp simple_memory_allocator.h
  group eiq/tensorflow-lite/tensorflow/lite/micro/kernels
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/micro/kernels/: activation_utils.h activations.h add.h circular_buffer.h conv.h depthwise_conv.h dequantize.h ethosu.h fully_connected.h hard_swish.h kernel_runner.h kernel_util.h leaky_relu.h logical.h logistic.h micro_ops.h micro_utils.h mul.h pooling.h prelu.h quantize.h softmax.h sub.h svdf.h activations_common.cpp add_common.cpp add_n.cpp arg_min_max.cpp assign_variable.cpp batch_to_space_nd.cpp call_once.cpp cast.cpp ceil.cpp circular_buffer.cpp circular_buffer_common.cpp comparisons.cpp concatenation.cpp conv_common.cpp cumsum.cpp depth_to_space.cpp depthwise_conv_common.cpp dequantize.cpp dequantize_common.cpp detection_postprocess.cpp elementwise.cpp elu.cpp ethosu.cpp exp.cpp expand_dims.cpp fill.cpp floor_div.cpp floor_mod.cpp fully_connected_common.cpp gather.cpp gather_nd.cpp hard_swish.cpp hard_swish_common.cpp if.cpp kernel_util.cpp l2_pool_2d.cpp l2norm.cpp leaky_relu_common.cpp log_softmax.cpp logical.cpp logical_common.cpp logistic_common.cpp maximum_minimum.cpp mirror_pad.cpp mul_common.cpp neg.cpp pack.cpp pad.cpp pooling_common.cpp prelu.cpp prelu_common.cpp quantize_common.cpp read_variable.cpp reduce.cpp reshape.cpp resize_bilinear.cpp resize_nearest_neighbor.cpp round.cpp shape.cpp slice.cpp softmax_common.cpp space_to_batch_nd.cpp space_to_depth.cpp split.cpp split_v.cpp squeeze.cpp strided_slice.cpp sub.cpp sub_common.cpp svdf_common.cpp tanh.cpp transpose.cpp unpack.cpp var_handle.cpp zeros_like.cpp activations.cpp floor.cpp leaky_relu.cpp logistic.cpp quantize.cpp transpose_conv.cpp
  group eiq/tensorflow-lite/tensorflow/lite/micro/memory_planner
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/micro/memory_planner/: greedy_memory_planner.h linear_memory_planner.h memory_plan_struct.h micro_memory_planner.h non_persistent_buffer_planner_shim.h greedy_memory_planner.cpp linear_memory_planner.cpp non_persistent_buffer_planner_shim.cpp
  group eiq/tensorflow-lite/tensorflow/lite/schema
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/schema/: schema_utils.cpp schema_generated.h schema_utils.h
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_usart.c
  group device
    ../../../../../devices/MIMXRT595S/: fsl_device_registers.h MIMXRT595S_cm33.h MIMXRT595S_cm33_features.h system_MIMXRT595S_cm33.c system_MIMXRT595S_cm33.h
  group startup
    ../../../../../devices/MIMXRT595S/arm/: startup_MIMXRT595S_cm33.S
  group flash_config
    ../../../flash_config/: flash_config.c flash_config.h
  group eiq/tensorflow-lite/tensorflow/lite/micro/kernels/cmsis_nn
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/micro/kernels/cmsis_nn/: add.cpp conv.cpp depthwise_conv.cpp fully_connected.cpp mul.cpp pooling.cpp softmax.cpp svdf.cpp
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
  group eiq/tensorflow-lite/third_party/flatbuffers
    ../../../../../middleware/eiq/tensorflow-lite/third_party/flatbuffers/: readme.md LICENSE.txt
  group eiq/tensorflow-lite/third_party/flatbuffers/include/flatbuffers
    ../../../../../middleware/eiq/tensorflow-lite/third_party/flatbuffers/include/flatbuffers/: allocator.h array.h base.h buffer.h buffer_ref.h default_allocator.h detached_buffer.h flatbuffer_builder.h flatbuffers.h flexbuffers.h stl_emulation.h strings.h struct.h table.h util.h vector.h vector_downward.h verifier.h
  group eiq/tensorflow-lite/third_party/gemmlowp
    ../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp/: LICENSE README.md
  group eiq/tensorflow-lite/third_party/gemmlowp/fixedpoint
    ../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp/fixedpoint/: fixedpoint.h
  group eiq/tensorflow-lite/third_party/gemmlowp/internal
    ../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp/internal/: detect_platform.h
  group eiq/tensorflow-lite/third_party/ruy
    ../../../../../middleware/eiq/tensorflow-lite/third_party/ruy/: LICENSE README.md
  group eiq/tensorflow-lite/third_party/ruy/ruy/profiler
    ../../../../../middleware/eiq/tensorflow-lite/third_party/ruy/ruy/profiler/: instrumentation.h
  group eiq/tensorflow-lite/third_party/cmsis/CMSIS/Core/Include
    ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/CMSIS/Core/Include/: cachel1_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm35p.h core_cm4.h core_cm55.h core_cm7.h core_sc000.h core_sc300.h core_star.h mpu_armv7.h mpu_armv8.h pmu_armv8.h tz_context.h
  group eiq/tensorflow-lite/third_party/cmsis/CMSIS/DSP/Include
    ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/CMSIS/DSP/Include/: arm_common_tables.h arm_common_tables_f16.h arm_const_structs.h arm_const_structs_f16.h arm_helium_utils.h arm_math.h arm_math_f16.h arm_math_memory.h arm_math_types.h arm_math_types_f16.h arm_mve_tables.h arm_mve_tables_f16.h arm_vec_math.h arm_vec_math_f16.h
  group eiq/tensorflow-lite/third_party/cmsis/CMSIS/DSP/Include/dsp
    ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/CMSIS/DSP/Include/dsp/: basic_math_functions.h basic_math_functions_f16.h bayes_functions.h bayes_functions_f16.h complex_math_functions.h complex_math_functions_f16.h controller_functions.h controller_functions_f16.h distance_functions.h distance_functions_f16.h fast_math_functions.h fast_math_functions_f16.h filtering_functions.h filtering_functions_f16.h interpolation_functions.h interpolation_functions_f16.h matrix_functions.h matrix_functions_f16.h none.h quaternion_math_functions.h statistics_functions.h statistics_functions_f16.h support_functions.h support_functions_f16.h svm_defines.h svm_functions.h svm_functions_f16.h transform_functions.h transform_functions_f16.h utils.h
  group eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN
    ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/: README.md
  group eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Include
    ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Include/: arm_nn_math_types.h arm_nn_tables.h arm_nn_types.h arm_nnfunctions.h arm_nnsupportfunctions.h
  group eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/ActivationFunctions
    ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/ActivationFunctions/: arm_nn_activations_q15.c arm_nn_activations_q7.c arm_relu6_s8.c arm_relu_q15.c arm_relu_q7.c
  group eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/BasicMathFunctions
    ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/BasicMathFunctions/: arm_elementwise_add_s8.c arm_elementwise_mul_s8.c
  group eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/ConcatenationFunctions
    ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/ConcatenationFunctions/: arm_concatenation_s8_w.c arm_concatenation_s8_x.c arm_concatenation_s8_y.c arm_concatenation_s8_z.c
  group eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/ConvolutionFunctions
    ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/ConvolutionFunctions/: arm_convolve_1_x_n_s8.c arm_convolve_1x1_HWC_q7_fast_nonsquare.c arm_convolve_1x1_s8_fast.c arm_convolve_HWC_q15_basic.c arm_convolve_HWC_q15_fast.c arm_convolve_HWC_q15_fast_nonsquare.c arm_convolve_HWC_q7_RGB.c arm_convolve_HWC_q7_basic.c arm_convolve_HWC_q7_basic_nonsquare.c arm_convolve_HWC_q7_fast.c arm_convolve_HWC_q7_fast_nonsquare.c arm_convolve_fast_s16.c arm_convolve_s16.c arm_convolve_s8.c arm_convolve_wrapper_s16.c arm_convolve_wrapper_s8.c arm_depthwise_conv_3x3_s8.c arm_depthwise_conv_s8.c arm_depthwise_conv_s8_opt.c arm_depthwise_conv_u8_basic_ver1.c arm_depthwise_conv_wrapper_s8.c arm_depthwise_separable_conv_HWC_q7.c arm_depthwise_separable_conv_HWC_q7_nonsquare.c arm_nn_depthwise_conv_s8_core.c arm_nn_mat_mult_kernel_q7_q15.c arm_nn_mat_mult_kernel_q7_q15_reordered.c arm_nn_mat_mult_kernel_s8_s16.c arm_nn_mat_mult_kernel_s8_s16_reordered.c arm_nn_mat_mult_s8.c
  group eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/FullyConnectedFunctions
    ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/FullyConnectedFunctions/: arm_fully_connected_mat_q7_vec_q15.c arm_fully_connected_mat_q7_vec_q15_opt.c arm_fully_connected_q15.c arm_fully_connected_q15_opt.c arm_fully_connected_q7.c arm_fully_connected_q7_opt.c arm_fully_connected_s16.c arm_fully_connected_s8.c
  group eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/NNSupportFunctions
    ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/NNSupportFunctions/: arm_nn_accumulate_q7_to_q15.c arm_nn_add_q7.c arm_nn_depthwise_conv_nt_t_padded_s8.c arm_nn_depthwise_conv_nt_t_s8.c arm_nn_mat_mul_core_1x_s8.c arm_nn_mat_mul_core_4x_s8.c arm_nn_mat_mul_kernel_s16.c arm_nn_mat_mult_nt_t_s8.c arm_nn_mult_q15.c arm_nn_mult_q7.c arm_nn_vec_mat_mult_t_s16.c arm_nn_vec_mat_mult_t_s8.c arm_nn_vec_mat_mult_t_svdf_s8.c arm_nntables.c arm_q7_to_q15_no_shift.c arm_q7_to_q15_reordered_no_shift.c arm_q7_to_q15_reordered_with_offset.c arm_q7_to_q15_with_offset.c
  group eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/PoolingFunctions
    ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/PoolingFunctions/: arm_avgpool_s8.c arm_max_pool_s8.c arm_pool_q7_HWC.c
  group eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/ReshapeFunctions
    ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/ReshapeFunctions/: arm_reshape_s8.c
  group eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/SVDFunctions
    ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/SVDFunctions/: arm_svdf_s8.c
  group eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/SoftmaxFunctions
    ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/SoftmaxFunctions/: arm_softmax_q15.c arm_softmax_q7.c arm_softmax_s8.c arm_softmax_u8.c arm_softmax_with_batch_q7.c
  group eiq/tensorflow-lite/third_party/cmsis
    ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/: LICENSE.txt README.md
target tensorflow_lite_micro_kws_cm33 flash_release (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT595SFFOC:cm33 NXP
  pack: NXP.MIMXRT595S_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: tensorflow_lite_micro_kws_cm33.out
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=4 wLevel=3
  c define: NDEBUG, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, __STDC_CONSTANT_MACROS, __CLK_TCK=1000000, CPU_MIMXRT595SFFOC_cm33, BOOT_HEADER_ENABLE=1, SDK_DEBUGCONSOLE_UART, ARM_MATH_CM33, __FPU_PRESENT=1, SDK_I2C_BASED_COMPONENT_USED=1, BOARD_USE_CODEC=1, CODEC_WM8904_ENABLE, DISABLEFLOAT16, TF_LITE_STATIC_MEMORY, CMSIS_NN, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: NDEBUG
  memory RVCT1: ROM 0x10000000 size 0x20000
  memory RVCT2: ROM 0x20000000 size 0x20000
  memory RVCT3: ROM 0x30000000 size 0x20000
  memory RVCT4: ROM 0x3000000 size 0x20000
  memory RVCT5: ROM 0x13000000 size 0x20000
  memory RVCT6: RAM 0x10300000 size 0x200000
  memory RVCT7: RAM 0x20300000 size 0x200000
  memory RVCT8: RAM 0x30300000 size 0x200000
  memory RVCT9: RAM 0x80000 size 0x280000
  memory RVCT10: RAM 0x300000 size 0x200000
  scatter file: MIMXRT595Sxxxx_cm33_flash.scf
  link misc: as above
