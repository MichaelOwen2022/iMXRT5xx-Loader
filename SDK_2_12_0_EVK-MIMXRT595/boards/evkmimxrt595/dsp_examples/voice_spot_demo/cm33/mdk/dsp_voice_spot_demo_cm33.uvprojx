# Keil uVision project dsp_voice_spot_demo_cm33.uvprojx, settings and files
target dsp_voice_spot_demo_cm33 debug (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT595SFFOC:cm33 NXP
  pack: NXP.MIMXRT595S_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: dsp_voice_spot_demo_cm33.out
  AfterMake: fromelf.exe --output "$L@L.bin" --bincombined "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DSP_IMAGE_COPY_TO_RAM=0, DEBUG, CPU_MIMXRT595SFFOC_cm33, BOOT_HEADER_ENABLE=1, DEBUG_CONSOLE_RX_ENABLE=0, SDK_I2C_BASED_COMPONENT_USED=1, BOARD_USE_CODEC=1, CODEC_WM8904_ENABLE, SERIAL_PORT_TYPE_UART=1, MCUXPRESSO_SDK
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../../../../../devices/MIMXRT595S/drivers;../../../../../../devices/MIMXRT595S/utilities;../../../../../../components/pca9420;../../../../../../components/codec/i2c;../../../../../../components/i2c;../../../../../../components/codec/wm8904;../../../../../../components/codec;../../../../../../components/codec/port/wm8904;../../../../../../components/codec/port;../../../../../../devices/MIMXRT595S;../../../../../../devices/MIMXRT595S/utilities/str;../../../../../../devices/MIMXRT595S/utilities/debug_console;../../../../../../components/uart;../../../../../../components/serial_manager;../../../../../../components/lists;../../../../flash_config;../../../../../../CMSIS/Core/Include
  asm define: DSP_IMAGE_COPY_TO_RAM=0, DEBUG
  asm include: ../../dsp/binary
  library: MicroLIB
  memory RVCT1: ROM 0x10000000 size 0x20000
  memory RVCT2: ROM 0x20000000 size 0x20000
  memory RVCT3: ROM 0x30000000 size 0x20000
  memory RVCT4: ROM 0x3000000 size 0x20000
  memory RVCT5: ROM 0x13000000 size 0x20000
  memory RVCT6: RAM 0x10300000 size 0x200000
  memory RVCT7: RAM 0x20300000 size 0x200000
  memory RVCT8: RAM 0x30300000 size 0x200000
  memory RVCT9: RAM 0x80000 size 0x280000
  memory RVCT10: RAM 0x300000 size 0x200000
  scatter file: MIMXRT595Sxxxx_cm33_ram.scf
  link misc: --remove --entry=Reset_Handler
  group source
    ../: main_cm33.c dsp_config.h incbin.S
  group board
    ../: pin_mux.c pin_mux.h dsp_support.c dsp_support.h pmic_support.c pmic_support.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group dsp_binary
    ../../dsp/binary/: dsp_reset_release.bin dsp_text_release.bin dsp_data_release.bin
  group drivers
    ../../../../../../devices/MIMXRT595S/drivers/: fsl_clock.h fsl_clock.c fsl_i2c.h fsl_i2c.c fsl_gpio.h fsl_gpio.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_power.h fsl_power.c fsl_reset.h fsl_reset.c fsl_dsp.h fsl_dsp.c fsl_inputmux.h fsl_inputmux.c fsl_i3c.h fsl_i3c.c fsl_flexspi.c fsl_flexspi.h fsl_cache.c fsl_cache.h fsl_usart.h fsl_usart.c fsl_flexcomm.h fsl_flexcomm.c fsl_iopctl.h fsl_inputmux_connections.h fsl_iap.h fsl_iap.c
  group utilities
    ../../../../../../devices/MIMXRT595S/utilities/: fsl_shell.c fsl_shell.h fsl_assert.c
    ../../../../../../devices/MIMXRT595S/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MIMXRT595S/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
  group pmic_driver
    ../../../../../../components/pca9420/: fsl_pca9420.h fsl_pca9420.c
  group codec
    ../../../../../../components/codec/i2c/: fsl_codec_i2c.h fsl_codec_i2c.c
    ../../../../../../components/codec/wm8904/: fsl_wm8904.h fsl_wm8904.c
    ../../../../../../components/codec/: fsl_codec_common.h fsl_codec_common.c
  group component/i2c
    ../../../../../../components/i2c/: fsl_adapter_i2c.h fsl_adapter_i3c.c
  group codec/port/wm8904
    ../../../../../../components/codec/port/wm8904/: fsl_codec_wm8904_adapter.c fsl_codec_wm8904_adapter.h
  group codec/port
    ../../../../../../components/codec/port/: fsl_codec_adapter.h
  group device
    ../../../../../../devices/MIMXRT595S/: fsl_device_registers.h MIMXRT595S_cm33.h MIMXRT595S_cm33_features.h system_MIMXRT595S_cm33.c system_MIMXRT595S_cm33.h
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_usart.c
  group component/serial_manager
    ../../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group flash_config
    ../../../../flash_config/: flash_config.c flash_config.h
  group startup
    ../../../../../../devices/MIMXRT595S/arm/: startup_MIMXRT595S_cm33.S
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
target dsp_voice_spot_demo_cm33 flash_debug (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT595SFFOC:cm33 NXP
  pack: NXP.MIMXRT595S_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: dsp_voice_spot_demo_cm33.out
  AfterMake: fromelf.exe --output "$L@L.bin" --bincombined "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DSP_IMAGE_COPY_TO_RAM=0, DEBUG, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, CPU_MIMXRT595SFFOC_cm33, BOOT_HEADER_ENABLE=1, DEBUG_CONSOLE_RX_ENABLE=0, SDK_I2C_BASED_COMPONENT_USED=1, BOARD_USE_CODEC=1, CODEC_WM8904_ENABLE, SERIAL_PORT_TYPE_UART=1, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: DSP_IMAGE_COPY_TO_RAM=0, DEBUG
  asm include: ../../dsp/binary
  library: MicroLIB
  memory RVCT1: ROM 0x10000000 size 0x20000
  memory RVCT2: ROM 0x20000000 size 0x20000
  memory RVCT3: ROM 0x30000000 size 0x20000
  memory RVCT4: ROM 0x3000000 size 0x20000
  memory RVCT5: ROM 0x13000000 size 0x20000
  memory RVCT6: RAM 0x10300000 size 0x200000
  memory RVCT7: RAM 0x20300000 size 0x200000
  memory RVCT8: RAM 0x30300000 size 0x200000
  memory RVCT9: RAM 0x80000 size 0x280000
  memory RVCT10: RAM 0x300000 size 0x200000
  scatter file: MIMXRT595Sxxxx_cm33_flash.scf
  link misc: --remove --entry=Reset_Handler
target dsp_voice_spot_demo_cm33 release (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT595SFFOC:cm33 NXP
  pack: NXP.MIMXRT595S_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: dsp_voice_spot_demo_cm33.out
  AfterMake: fromelf.exe --output "$L@L.bin" --bincombined "#L"
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DSP_IMAGE_COPY_TO_RAM=1, NDEBUG, CPU_MIMXRT595SFFOC_cm33, BOOT_HEADER_ENABLE=1, DEBUG_CONSOLE_RX_ENABLE=0, SDK_I2C_BASED_COMPONENT_USED=1, BOARD_USE_CODEC=1, CODEC_WM8904_ENABLE, SERIAL_PORT_TYPE_UART=1, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: DSP_IMAGE_COPY_TO_RAM=1, NDEBUG
  asm include: ../../dsp/binary
  library: MicroLIB
  memory RVCT1: ROM 0x10000000 size 0x20000
  memory RVCT2: ROM 0x20000000 size 0x20000
  memory RVCT3: ROM 0x30000000 size 0x20000
  memory RVCT4: ROM 0x3000000 size 0x20000
  memory RVCT5: ROM 0x13000000 size 0x20000
  memory RVCT6: RAM 0x10300000 size 0x200000
  memory RVCT7: RAM 0x20300000 size 0x200000
  memory RVCT8: RAM 0x30300000 size 0x200000
  memory RVCT9: RAM 0x80000 size 0x280000
  memory RVCT10: RAM 0x300000 size 0x200000
  scatter file: MIMXRT595Sxxxx_cm33_ram.scf
  link misc: --remove --entry=Reset_Handler
target dsp_voice_spot_demo_cm33 flash_release (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT595SFFOC:cm33 NXP
  pack: NXP.MIMXRT595S_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: dsp_voice_spot_demo_cm33.out
  AfterMake: fromelf.exe --output "$L@L.bin" --bincombined "#L"
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DSP_IMAGE_COPY_TO_RAM=1, NDEBUG, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, CPU_MIMXRT595SFFOC_cm33, BOOT_HEADER_ENABLE=1, DEBUG_CONSOLE_RX_ENABLE=0, SDK_I2C_BASED_COMPONENT_USED=1, BOARD_USE_CODEC=1, CODEC_WM8904_ENABLE, SERIAL_PORT_TYPE_UART=1, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: DSP_IMAGE_COPY_TO_RAM=1, NDEBUG
  asm include: ../../dsp/binary
  library: MicroLIB
  memory RVCT1: ROM 0x10000000 size 0x20000
  memory RVCT2: ROM 0x20000000 size 0x20000
  memory RVCT3: ROM 0x30000000 size 0x20000
  memory RVCT4: ROM 0x3000000 size 0x20000
  memory RVCT5: ROM 0x13000000 size 0x20000
  memory RVCT6: RAM 0x10300000 size 0x200000
  memory RVCT7: RAM 0x20300000 size 0x200000
  memory RVCT8: RAM 0x30300000 size 0x200000
  memory RVCT9: RAM 0x80000 size 0x280000
  memory RVCT10: RAM 0x300000 size 0x200000
  scatter file: MIMXRT595Sxxxx_cm33_flash.scf
  link misc: --remove --entry=Reset_Handler
