# IAR project emwin_gui_demo.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT595S_M33 NXP MIMXRT595S_M33
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CPU_MIMXRT595SFFOC_cm33; BOOT_HEADER_ENABLE=1; BOARD_ENABLE_PSRAM_CACHE=0; SSD1963_DATA_WITDH=8; FLEXIO_MCULCD_DATA_BUS_WIDTH=8; SDK_I2C_BASED_COMPONENT_USED=1; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../devices/MIMXRT595S/drivers; ../../../../../components/ssd1963; ../../../../../components/video/display/dbi; ../../../../../components/video/display/dbi/flexio; ../../../../../components/video/display/dc/ssd1963; ../../../../../components/video/display/dc/lcdif; ../../../../../components/video; ../../../../../components/video/display; ../../../../../components/video/display/rm68191; ../../../../../components/video/display/mipi_dsi_cmd; ../../../../../components/video/display/rm68200; ../../../../../components/video/display/rm67162; ../../../../../components/video/display/dc/dsi_cmd; ../../../../../components/ft3267; ../../../../../components/gt911; ../../../../../components/ft5406; ../../../../../devices/MIMXRT595S/utilities/debug_console_lite; ../../../../../components/video/display/hx8394; ../../../../../middleware/emwin/emWin_header; ../../../../../middleware/emwin/emWin_Config; ../../../../../devices/MIMXRT595S; ../../../../../components/uart; ../../../../../components/lists; ../../../flash_config; ../../../../../CMSIS/Core/Include; ../../../../../components/video/display/dc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  OBJCOPY.OOCOutputFile: sdk20-app.bin
  ILINK.IlinkOutputFile: emwin_gui_demo.out
  ILINK.IlinkConfigDefines: __stack_size__=0x800
  ILINK.IlinkIcfFile: MIMXRT595Sxxxx_cm33_ram.icf
  ILINK.IlinkAdditionalLibs: ../../../../../middleware/emwin/emWin_library/IAR/emWin_M33.a
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flash_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; BOOT_HEADER_ENABLE=1; CPU_MIMXRT595SFFOC_cm33; BOARD_ENABLE_PSRAM_CACHE=0; SSD1963_DATA_WITDH=8; FLEXIO_MCULCD_DATA_BUS_WIDTH=8; SDK_I2C_BASED_COMPONENT_USED=1; MCUXPRESSO_SDK
  ILINK.IlinkIcfFile: MIMXRT595Sxxxx_cm33_flash.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT595SFFOC_cm33; BOOT_HEADER_ENABLE=1; BOARD_ENABLE_PSRAM_CACHE=0; SSD1963_DATA_WITDH=8; FLEXIO_MCULCD_DATA_BUS_WIDTH=8; SDK_I2C_BASED_COMPONENT_USED=1; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
configuration flash_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; CPU_MIMXRT595SFFOC_cm33; BOOT_HEADER_ENABLE=1; NDEBUG; BOARD_ENABLE_PSRAM_CACHE=0; SSD1963_DATA_WITDH=8; FLEXIO_MCULCD_DATA_BUS_WIDTH=8; SDK_I2C_BASED_COMPONENT_USED=1; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: MIMXRT595Sxxxx_cm33_flash.icf
  group board
    ../: display_support.h display_support.c pin_mux.c pin_mux.h emwin_support.c emwin_support.h board.c board.h clock_config.c clock_config.h
  group source
    ../: emwin_gui_demo.c
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MIMXRT595S/drivers/: fsl_flexio.c fsl_flexio.h fsl_flexio_mculcd.c fsl_flexio_mculcd.h fsl_dma.c fsl_dma.h fsl_clock.h fsl_clock.c fsl_gpio.h fsl_gpio.c fsl_inputmux.h fsl_inputmux.c fsl_flexio_mculcd_smartdma.c fsl_flexio_mculcd_smartdma.h fsl_mipi_dsi.c fsl_mipi_dsi.h fsl_lcdif.h fsl_lcdif.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_i2c.h fsl_i2c.c fsl_mipi_dsi_smartdma.c fsl_mipi_dsi_smartdma.h fsl_power.h fsl_power.c fsl_flexspi.c fsl_flexspi.h fsl_cache.c fsl_cache.h fsl_usart.h fsl_usart.c fsl_flexcomm.h fsl_flexcomm.c fsl_iopctl.h fsl_reset.h fsl_reset.c fsl_smartdma.h fsl_smartdma.c fsl_smartdma_prv.h fsl_inputmux_connections.h fsl_soc_mipi_dsi.h fsl_iap.h fsl_iap.c
  group lcdc
    ../../../../../components/ssd1963/: fsl_ssd1963.h fsl_ssd1963.c
  group video
    ../../../../../components/video/display/dbi/: fsl_dbi.h
    ../../../../../components/video/display/dbi/flexio/: fsl_dbi_flexio_smartdma.h fsl_dbi_flexio_smartdma.c
    ../../../../../components/video/display/dc/ssd1963/: fsl_dc_fb_ssd1963.h fsl_dc_fb_ssd1963.c
    ../../../../../components/video/display/dc/lcdif/: fsl_dc_fb_lcdif.h fsl_dc_fb_lcdif.c
    ../../../../../components/video/: fsl_video_common.h fsl_video_common.c
    ../../../../../components/video/display/: fsl_display.h
    ../../../../../components/video/display/rm68191/: fsl_rm68191.h fsl_rm68191.c
    ../../../../../components/video/display/mipi_dsi_cmd/: fsl_mipi_dsi_cmd.h fsl_mipi_dsi_cmd.c
    ../../../../../components/video/display/rm68200/: fsl_rm68200.h fsl_rm68200.c
    ../../../../../components/video/display/rm67162/: fsl_rm67162.h fsl_rm67162.c
    ../../../../../components/video/display/dc/dsi_cmd/: fsl_dc_fb_dsi_cmd.h fsl_dc_fb_dsi_cmd.c
    ../../../../../components/video/display/hx8394/: fsl_hx8394.h fsl_hx8394.c
    ../../../../../components/video/display/dc/: fsl_dc_fb.h
  group touchpanel
    ../../../../../components/ft3267/: fsl_ft3267.h fsl_ft3267.c
    ../../../../../components/gt911/: fsl_gt911.h fsl_gt911.c
    ../../../../../components/ft5406/: fsl_ft5406.h fsl_ft5406.c
  group utilities
    ../../../../../devices/MIMXRT595S/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group emwin/emWin_header
    ../../../../../middleware/emwin/emWin_header/: AppWizard.h BUTTON.h BUTTON_Private.h CALENDAR.h CHECKBOX.h CHECKBOX_Private.h CHOOSECOLOR.h CHOOSEFILE.h DIALOG.h DIALOG_Type.h DROPDOWN.h DROPDOWN_Private.h EDIT.h EDIT_Private.h FRAMEWIN.h FRAMEWIN_Private.h GAUGE.h GAUGE_Private.h GRAPH.h GRAPH_Private.h GUI.h GUIDRV_BitPlains.h GUIDRV_DCache.h GUIDRV_DCache_Private.h GUIDRV_Dist.h GUIDRV_FlexColor.h GUIDRV_FlexColor_Private.h GUIDRV_IST3088.h GUIDRV_IST3088_Private.h GUIDRV_Lin.h GUIDRV_Lin_Opt_16.h GUIDRV_Lin_Opt_24.h GUIDRV_Lin_Opt_32.h GUIDRV_Lin_Opt_8.h GUIDRV_Lin_Private.h GUIDRV_NoOpt_1_8.h GUIDRV_Null.h GUIDRV_S1D13748.h GUIDRV_S1D13748_Private.h GUIDRV_S1D13781.h GUIDRV_S1D13781_Private.h GUIDRV_S1D15G00.h GUIDRV_SH_MEM.h GUIDRV_SH_MEM_Private.h GUIDRV_SLin.h GUIDRV_SLin_Private.h GUIDRV_SPage.h GUIDRV_SPage_Private.h GUIDRV_SSD1926.h GUIDRV_SSD1926_Private.h GUIDRV_Template.h GUIDRV_TemplateI.h GUIDRV_TemplateI_Private.h GUITDRV_ADS7846.h GUI_ARRAY.h GUI_ARRAY_Private.h GUI_BMP_Private.h GUI_ConfDefaults.h GUI_Debug.h GUI_FontIntern.h GUI_GCache_Private.h GUI_GIF_Private.h GUI_HOOK.h GUI_JPEG_Private.h GUI_Private.h GUI_SPRITE_Private.h GUI_SPY_Private.h GUI_SetOrientation.h GUI_SetOrientationCX.h GUI_Type.h GUI_VNC.h GUI_Version.h GUI__BiDi2_Brackets_800.h GUI__BiDi2_Types_800.h Global.h HEADER.h HEADER_Private.h ICONVIEW.h ICONVIEW_Private.h IMAGE.h IMAGE_Private.h IP_FS.h KEYBOARD.h KEYBOARD_Private.h KNOB.h KNOB_Private.h LCD.h LCD_ConfDefaults.h LCD_Private.h LCD_Protected.h LCD_SIM.h LISTBOX.h LISTBOX_Private.h LISTVIEW.h LISTVIEW_Private.h LISTWHEEL.h LISTWHEEL_Private.h MENU.h MENU_Private.h MESSAGEBOX.h MULTIEDIT.h MULTIEDIT_Private.h MULTIPAGE.h MULTIPAGE_Private.h PROGBAR.h PROGBAR_Private.h QRCODE.h QRCODE_Private.h RADIO.h RADIO_Private.h ROTARY.h ROTARY_Private.h SCROLLBAR.h SCROLLBAR_Private.h SEGGER.h SLIDER.h SLIDER_Private.h SPINBOX.h SPINBOX_Private.h SWIPELIST.h SWIPELIST_Private.h SWITCH.h SWITCH_Private.h TEXT.h TEXT_Private.h TREEVIEW.h TREEVIEW_Private.h WIDGET.h WINDOW_Private.h WM.h WM_GUI.h WM_Intern.h
  group emwin/emWin_Config
    ../../../../../middleware/emwin/emWin_Config/: GUIConf.h LCDConf.h
  group device
    ../../../../../devices/MIMXRT595S/: fsl_device_registers.h MIMXRT595S_cm33.h MIMXRT595S_cm33_features.h system_MIMXRT595S_cm33.c system_MIMXRT595S_cm33.h
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_usart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group flash_config
    ../../../flash_config/: flash_config.c flash_config.h
  group startup
    ../../../../../devices/MIMXRT595S/iar/: startup_MIMXRT595S_cm33.s
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
