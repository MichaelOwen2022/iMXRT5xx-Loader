# Keil uVision project iMXRT5xx-Loader.uvprojx, settings and files
target iMXRT5xx-NOR (6150000::V6.15::ARMCLANG)
  device: MIMXRT595SFFOC:cm33 NXP
  pack: NXP.MIMXRT595S_DFP.15.0.0
  cpu: IRAM(0x00280000,0x280000) IRAM2(0x00080000,0x200000) IROM(0x03000000,0x020000) IROM2(0x13000000,0x020000) XRAM(0x10080000,0x200000) XRAM2(0x20080000,0x200000) XRAM3(0x30080000,0x200000) XROM(0x10000000,0x020000) XROM2(0x20000000,0x020000) XROM3(0x30000000,0x020000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: iMXRT5xx-Loader
  AfterMake: cmd.exe /C copy "Objects\%L" ".\source\JLink\Devices\NXP\iMXRT5xx\iMXRT5xx-NOR.FLM"
  c flags: Optim=2 v6Lang=3 v6LangP=3 wLevel=1
  c define: CPU_MIMXRT595SFFOC_cm33, MCUXPRESSO_SDK
  c include: source\log;source\board;source\norflash;source\watchdog;source\SEGGER;SDK_2_12_0_EVK-MIMXRT595\CMSIS\Core\Include;SDK_2_12_0_EVK-MIMXRT595\devices\MIMXRT595S;SDK_2_12_0_EVK-MIMXRT595\devices\MIMXRT595S\drivers
  memory RVCT1: ROM 0x10000000 size 0x20000
  memory RVCT2: ROM 0x20000000 size 0x20000
  memory RVCT3: ROM 0x30000000 size 0x20000
  memory RVCT4: ROM 0x3000000 size 0x20000
  memory RVCT5: ROM 0x13000000 size 0x20000
  memory RVCT6: RAM 0x10080000 size 0x200000
  memory RVCT7: RAM 0x20080000 size 0x200000
  memory RVCT8: RAM 0x30080000 size 0x200000
  memory RVCT9: RAM 0x280000 size 0x280000
  memory RVCT10: RAM 0x80000 size 0x200000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group SEGGER
    ./source/SEGGER/: FlashDev.c FlashOS.h FlashPrg.c
  group board
    ./source/board/: clock_config.c clock_config.h pin_mux.c pin_mux.h
  group MIMXRT595
    ./SDK_2_12_0_EVK-MIMXRT595/devices/MIMXRT595S/drivers/: fsl_clock.c fsl_clock.h fsl_common_arm.c fsl_common_arm.h fsl_flexspi.c fsl_flexspi.h fsl_gpio.c fsl_gpio.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h fsl_usart.c fsl_usart.h fsl_flexcomm.c fsl_flexcomm.h fsl_i2c.c fsl_i2c.h
    ./SDK_2_12_0_EVK-MIMXRT595/devices/MIMXRT595S/: system_MIMXRT595S_cm33.c system_MIMXRT595S_cm33.h
  group log
    ./source/log/: log.c log.h
  group watchdog
    ./source/watchdog/: watchdog.c watchdog.h watchdog_cfg.h watchdog_external.c watchdog_internal.c
  group norflash
    ./source/norflash/: norflash.c norflash.h norflash_cfg.h norflash_dev.h norflash_dev_gd25lx512.c norflash_dev_mx25um512.c norflash_drv.h norflash_drv_flexspi.c norflash_lut.h
